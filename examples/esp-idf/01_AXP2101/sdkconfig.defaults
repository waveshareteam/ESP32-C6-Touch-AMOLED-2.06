## examples/esp-idf/01_AXP2101/sdkconfig.defaults
```kconfig
CONFIG_IDF_TARGET="esp32c6"
CONFIG_ESPTOOLPY_FLASHSIZE_16MB=y
CONFIG_PMU_I2C_SCL=7
CONFIG_PMU_I2C_SDA=8
CONFIG_PMU_INTERRUPT_PIN=-1
```
